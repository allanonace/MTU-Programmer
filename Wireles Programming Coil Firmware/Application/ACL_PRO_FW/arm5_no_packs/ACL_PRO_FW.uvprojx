# Keil uVision project ACL_PRO_FW.uvprojx, settings and files
target nrf52832_xxaa (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: ACL_PRO_FW +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: DEBUG BL_SETTINGS_ACCESS_ONLY BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --reduce_paths
  c include: ..\libs\config;..\libs\components;..\libs\components\ble\ble_advertising;..\libs\components\ble\ble_services\ble_dfu;..\libs\components\ble\common;..\libs\components\ble\nrf_ble_gatt;..\libs\components\ble\peer_manager;..\libs\components\boards;..\libs\components\drivers_nrf\clock;..\libs\components\drivers_nrf\common;..\libs\components\drivers_nrf\delay;..\libs\components\drivers_nrf\gpiote;..\libs\components\drivers_nrf\hal;..\libs\components\drivers_nrf\uart;..\libs\components\libraries\atomic;..\libs\components\libraries\atomic_fifo;..\libs\components\libraries\balloc;..\libs\components\libraries\bootloader\dfu;..\libs\components\libraries\bsp;..\libs\components\libraries\button;..\libs\components\libraries\crc16;..\libs\components\libraries\experimental_log;..\libs\components\libraries\experimental_log\src;..\libs\components\libraries\experimental_memobj;..\libs\components\libraries\experimental_section_vars;..\libs\components\libraries\fds;..\libs\components\libraries\fstorage;..\libs\components\libraries\mutex;..\libs\components\libraries\pwr_mgmt;..\libs\components\libraries\scheduler;..\libs\components\libraries\strerror;..\libs\components\libraries\svc;..\libs\components\libraries\timer;..\libs\components\libraries\util;..\libs\components\softdevice\common;..\libs\components\softdevice\s132\headers;..\libs\components\softdevice\s132\headers\nrf52;..\libs\components\toolchain;..\libs\external\fprintf;..\libs\external\segger_rtt;..\src\ble_uart_service;..\libs\aes;..\libs\components\libraries\uart;..\libs\components\libraries\fifo;..\libs\components\drivers_nrf\saadc;..\libs\components\drivers_nrf\hal;..\libs\components\drivers_nrf\timer;..\libs\components\drivers_nrf\ppi;..\src\ble_control_service;..\libs\components\drivers_nrf\ble_flash;..\src
  asm define: BL_SETTINGS_ACCESS_ONLY BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBL_SETTINGS_ACCESS_ONLY,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_DFU_SVCI_ENABLED,-DNRF_SD_BLE_API_VERSION=5,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  asm include: ..\libs\config;..\libs\components;..\libs\components\ble\ble_advertising;..\libs\components\ble\ble_services\ble_dfu;..\libs\components\ble\common;..\libs\components\ble\nrf_ble_gatt;..\libs\components\ble\peer_manager;..\libs\components\boards;..\libs\components\drivers_nrf\clock;..\libs\components\drivers_nrf\common;..\libs\components\drivers_nrf\delay;..\libs\components\drivers_nrf\gpiote;..\libs\components\drivers_nrf\hal;..\libs\components\drivers_nrf\uart;..\libs\components\libraries\atomic;..\libs\components\libraries\atomic_fifo;..\libs\components\libraries\balloc;..\libs\components\libraries\bootloader\dfu;..\libs\components\libraries\bsp;..\libs\components\libraries\button;..\libs\components\libraries\crc16;..\libs\components\libraries\experimental_log;..\libs\components\libraries\experimental_log\src;..\libs\components\libraries\experimental_memobj;..\libs\components\libraries\experimental_section_vars;..\libs\components\libraries\fds;..\libs\components\libraries\fstorage;..\libs\components\libraries\mutex;..\libs\components\libraries\pwr_mgmt;..\libs\components\libraries\scheduler;..\libs\components\libraries\strerror;..\libs\components\libraries\svc;..\libs\components\libraries\timer;..\libs\components\libraries\util;..\libs\components\softdevice\common;..\libs\components\softdevice\s132\headers;..\libs\components\softdevice\s132\headers\nrf52;..\libs\components\toolchain;..\libs\external\fprintf;..\libs\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x4f000
  memory RVCT9: RAM 0x20002700 size 0xd900
  link misc: --diag_suppress 6330
  group Application
    ../src/: main.c timers_management.c timers_management.h globals.c data_management.c data_management.h encryption_management.c encryption_management.h state_machine_management.c state_machine_management.h uart_management.c uart_management.h versions_fw_hw.h flash_management.c flash_management.h connection_control_management.c connection_control_management.h md5.c md5.h defines_tests.h watchdog_management.c watchdog_management.h
    ../libs/config/: sdk_config.h
    ../libs/aes/: aes_core.c
  group Aclara BLE
    ../src/: bluetooth_management.c bluetooth_management.h
  group Service Virtual UART
    ../src/ble_uart_service/: ble_uart_service.c ble_uart_service.h ble_uart_char_RX.c ble_uart_char_RX.h ble_uart_char_TX.c ble_uart_char_TX.h
  group Service Control
    ../src/ble_control_service/: ble_control_service.c ble_control_service.h ble_control_service_char_frame.c ble_control_service_char_frame.h ble_control_service_char_pass.c ble_control_service_char_pass.h
  group Service Device Info
    ../src/: ble_device_configuration_service.c ble_device_configuration_service.h ble_device_configuration_service_char_version.c ble_device_configuration_service_char_version.h ble_device_configuration_service_char_battery.c ble_device_configuration_service_char_battery.h
  group Service UART Configuration
    ../src/: ble_uart_configuration_service.c ble_uart_configuration_service.h ble_uart_configuration_service_char_baudrate.c ble_uart_configuration_service_char_baudrate.h ble_uart_configuration_service_char_parity.c ble_uart_configuration_service_char_parity.h
  group Service Time Configuration
    ../src/: ble_time_configuration_service.c ble_time_configuration_service.h ble_time_configuration_service_char_advertising.c ble_time_configuration_service_char_advertising.h ble_time_configuration_service_char_on_timeout.c ble_time_configuration_service_char_on_timeout.h ble_time_configuration_service_char_pairing_timeout.c ble_time_configuration_service_char_pairing_timeout.h ble_time_configuration_service_char_wake_up_from_sleep.c ble_time_configuration_service_char_wake_up_from_sleep.h ble_time_configuration_service_char_on_to_pairing.c ble_time_configuration_service_char_on_to_pairing.h ble_time_configuration_service_char_power_off.c ble_time_configuration_service_char_power_off.h ble_time_configuration_service_char_bootloader.c ble_time_configuration_service_char_bootloader.h ble_time_configuration_service_char_cancel_bootloader.c ble_time_configuration_service_char_cancel_bootloader.h
  group Battery
    ../src/: battery_management.c battery_management.h adc_batt_management.c adc_batt_management.h adc_ntc_management.c adc_ntc_management.h
  group GPIO
    ../src/: pinout_ACL_PRO.h gpio_management.c gpio_management.h leds_management.c leds_management.h button_management.c button_management.h
  group Board Definition
    ../libs/components/boards/: boards.c
  group Board Support
    ../libs/components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group nRF_BLE
    ../libs/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../libs/components/ble/ble_advertising/: ble_advertising.c
    ../libs/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group nRF_Drivers
    ../libs/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../libs/components/drivers_nrf/common/: nrf_drv_common.c
    ../libs/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../libs/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../libs/components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../libs/components/drivers_nrf/hal/: nrf_saadc.c
    ../libs/components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../libs/components/drivers_nrf/timer/: nrf_drv_timer.c
    ../libs/components/drivers_nrf/ble_flash/: ble_flash.c
  group nRF_Libraries
    ../libs/components/libraries/button/: app_button.c
    ../libs/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../libs/components/libraries/scheduler/: app_scheduler.c
    ../libs/components/libraries/timer/: app_timer.c
    ../libs/components/libraries/crc16/: crc16.c
    ../libs/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../libs/components/libraries/balloc/: nrf_balloc.c
    ../libs/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../libs/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../libs/components/libraries/experimental_memobj/: nrf_memobj.c
    ../libs/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../libs/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../libs/components/libraries/strerror/: nrf_strerror.c
    ../libs/components/libraries/uart/: app_uart_fifo.c
    ../libs/components/libraries/fifo/: app_fifo.c
  group nRF_Log
    ../libs/components/libraries/experimental_log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_SVC
    ../libs/components/libraries/bootloader/dfu/: nrf_dfu_svci.c
  group nRF_Segger_RTT
    ../libs/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../libs/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
target flash_s132_nrf52_5.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: as above
  output: s132_nrf52_5.0.0_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c misc: --reduce_paths
  c include: ..\libs\config;..\config
  asm misc: --cpreproc_opts=
  asm include: ..\libs\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x23000 size 0x55000
  memory RVCT9: RAM 0x20002180 size 0xde80
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
