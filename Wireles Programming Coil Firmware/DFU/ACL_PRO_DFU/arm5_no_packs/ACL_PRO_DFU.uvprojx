# Keil uVision project ACL_PRO_DFU.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.16.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: ACL_PRO_DFU +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52 NRF52832_XXAA NRF52_PAN_74 NRF_DFU_SETTINGS_VERSION=1 NRF_DFU_SVCI_ENABLED NRF_SD_BLE_API_VERSION=5 S132 SOFTDEVICE_PRESENT SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION SWI_DISABLE0 __HEAP_SIZE=0
  c misc: --reduce_paths
  c include: ..\libs\config;..\libs\components\ble\common;..\libs\components\boards;..\libs\components\drivers_nrf\clock;..\libs\components\drivers_nrf\common;..\libs\components\drivers_nrf\delay;..\libs\components\drivers_nrf\hal;..\libs\components\drivers_nrf\rng;..\libs\components\libraries\atomic;..\libs\components\libraries\atomic_fifo;..\libs\components\libraries\balloc;..\libs\components\libraries\bootloader;..\libs\components\libraries\bootloader\ble_dfu;..\libs\components\libraries\bootloader\dfu;..\libs\components\libraries\crc32;..\libs\components\libraries\crypto;..\libs\components\libraries\crypto\backend\micro_ecc;..\libs\components\libraries\crypto\backend\nrf_crypto_sw;..\libs\components\libraries\experimental_log;..\libs\components\libraries\experimental_log\src;..\libs\components\libraries\experimental_memobj;..\libs\components\libraries\experimental_section_vars;..\libs\components\libraries\fstorage;..\libs\components\libraries\hci;..\libs\components\libraries\mem_manager;..\libs\components\libraries\queue;..\libs\components\libraries\scheduler;..\libs\components\libraries\sha256;..\libs\components\libraries\strerror;..\libs\components\libraries\svc;..\libs\components\libraries\timer;..\libs\components\libraries\util;..\libs\components\softdevice\common;..\libs\components\softdevice\s132\headers;..\libs\components\softdevice\s132\headers\nrf52;..\libs\components\toolchain;..\..;..\..\..\dfu_req_handling;..\libs\external\micro-ecc\micro-ecc;..\libs\external\nano-pb;..\config;..\libs\components\libraries\button;..\libs\components\drivers_nrf\gpiote;..\libs\components\drivers_nrf\saadc;..\libs\components\drivers_nrf\hal;..\src;..\libs\components\drivers_nrf\ble_flash
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DBOARD_PCA10040,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74,-DNRF_DFU_SETTINGS_VERSION=1,-DNRF_DFU_SVCI_ENABLED,-DNRF_SD_BLE_API_VERSION=5,-DS132,-DSOFTDEVICE_PRESENT,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-DSWI_DISABLE0,-D__HEAP_SIZE=0
  asm include: ..\libs\config;..\libs\components\ble\common;..\libs\components\boards;..\libs\components\drivers_nrf\clock;..\libs\components\drivers_nrf\common;..\libs\components\drivers_nrf\delay;..\libs\components\drivers_nrf\hal;..\libs\components\drivers_nrf\rng;..\libs\components\libraries\atomic;..\libs\components\libraries\atomic_fifo;..\libs\components\libraries\balloc;..\libs\components\libraries\bootloader;..\libs\components\libraries\bootloader\ble_dfu;..\libs\components\libraries\bootloader\dfu;..\libs\components\libraries\crc32;..\libs\components\libraries\crypto;..\libs\components\libraries\crypto\backend\micro_ecc;..\libs\components\libraries\crypto\backend\nrf_crypto_sw;..\libs\components\libraries\experimental_log;..\libs\components\libraries\experimental_log\src;..\libs\components\libraries\experimental_memobj;..\libs\components\libraries\experimental_section_vars;..\libs\components\libraries\fstorage;..\libs\components\libraries\hci;..\libs\components\libraries\mem_manager;..\libs\components\libraries\queue;..\libs\components\libraries\scheduler;..\libs\components\libraries\sha256;..\libs\components\libraries\strerror;..\libs\components\libraries\svc;..\libs\components\libraries\timer;..\libs\components\libraries\util;..\libs\components\softdevice\common;..\libs\components\softdevice\s132\headers;..\libs\components\softdevice\s132\headers\nrf52;..\libs\components\toolchain;..\..;..\..\..\dfu_req_handling;..\libs\external\micro-ecc\micro-ecc;..\libs\external\nano-pb;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x74000 size 0xa000
  memory RVCT9: RAM 0x20002830 size 0xd7d0
  link misc: --diag_suppress 6330
  group None
    ../src/dfu_req_handling/: dfu-cc.pb.c dfu_public_key.c dfu_req_handling.c
  group Application
    ../src/: main.c button_management.c button_management.h gpio_management.c gpio_management.h leds_management.c leds_management.h pinout_ACL_PRO.h timer_managment.c timer_managment.h dfu_states_management.c dfu_states_management.h pruebas.h dfu_launch_management.c dfu_launch_management.h adc_batt_management.c adc_batt_management.h battery_management.c battery_management.h flash_management.c flash_management.h watchdog_management.c watchdog_management.h adc_ntc_management.c adc_ntc_management.h
    ../libs/config/: sdk_config.h
  group Board Definition
    ../libs/components/boards/: boards.c
  group nRF_BLE
    ../libs/components/ble/common/: ble_srv_common.c
  group nRF_BLE_DFU
    ../libs/components/libraries/bootloader/ble_dfu/: nrf_ble_dfu.c
  group nRF_Bootloader
    ../libs/components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_app_start_asm.c nrf_bootloader_info.c
    ../libs/components/libraries/bootloader/dfu/: nrf_dfu.c nrf_dfu_flash.c nrf_dfu_handling_error.c nrf_dfu_mbr.c nrf_dfu_settings.c nrf_dfu_settings_svci.c nrf_dfu_transport.c nrf_dfu_utils.c
  group nRF_Crypto
    ../libs/components/libraries/crypto/: nrf_crypto_ecdh.c nrf_crypto_ecdsa.c nrf_crypto_hash.c nrf_crypto_init.c nrf_crypto_keys.c nrf_crypto_mem.c nrf_crypto_rng.c
  group nRF_Crypto backends
    ../libs/components/libraries/crypto/backend/micro_ecc/: micro_ecc_lib_ecdh.c micro_ecc_lib_ecdsa.c micro_ecc_lib_init.c micro_ecc_lib_keys.c micro_ecc_lib_shared.c
    ../libs/components/libraries/crypto/backend/nrf_crypto_sw/: nrf_crypto_sw_hash.c nrf_crypto_sw_rng.c
  group nRF_Drivers
    ../libs/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../libs/components/drivers_nrf/common/: nrf_drv_common.c
    ../libs/components/drivers_nrf/rng/: nrf_drv_rng.c
    ../libs/components/drivers_nrf/hal/: nrf_nvmc.c nrf_saadc.c
    ../libs/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../libs/components/drivers_nrf/saadc/: nrf_drv_saadc.c
  group nRF_Libraries
    ../libs/components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../libs/components/libraries/scheduler/: app_scheduler.c
    ../libs/components/libraries/timer/: app_timer.c
    ../libs/components/libraries/crc32/: crc32.c
    ../libs/components/libraries/hci/: hci_mem_pool.c
    ../libs/components/libraries/mem_manager/: mem_manager.c
    ../libs/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../libs/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../libs/components/libraries/queue/: nrf_queue.c
    ../libs/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../libs/components/libraries/strerror/: nrf_strerror.c
    ../libs/components/libraries/sha256/: sha256.c
    ../libs/components/libraries/button/: app_button.c
  group nRF_SVC
    ../libs/components/libraries/bootloader/dfu/: nrf_dfu_svci.c nrf_dfu_svci_handler.c
    ../libs/components/libraries/svc/: nrf_svc_handler.c
  group nRF_SoftDevice
    ../libs/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group nRF_micro-ecc
    ../libs/external/micro-ecc/nrf52hf_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nano-pb
    ../libs/external/nano-pb/: pb_common.c pb_decode.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
